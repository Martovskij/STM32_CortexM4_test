# Keil uVision project Discovery_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Discovery_test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\Usr;.\SPL_CMSIS;.\SPL_CMSIS\STM32F4xx_StdPeriph_Driver;.\STM32_CPAL_Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CPAL
    ./STM32_CPAL_Driver/: cpal_hal.c cpal_i2c.c cpal_i2c_hal_stm32f4xx.c cpal_usercallback_template.c cpal.h cpal_conf.h cpal_i2c.h cpal_i2c_hal_stm32f4xx.h
  group SPL & CMSIS
    ./SPL_CMSIS/: arm_common_tables.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h stm32f4xx_it.c system_stm32f4xx.c startup_stm32f4xx.s
    ./SPL_CMSIS/STM32F4xx_StdPeriph_Driver/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Usr
    ./Usr/: adc.c CS43L22.c GPIO.c I2C.c LIS302DL.c main.c SPI.c timer.c adc.h CS43L22.h GPIO.h I2C.h LIS302DL.h main.h SPI.h timer.h
